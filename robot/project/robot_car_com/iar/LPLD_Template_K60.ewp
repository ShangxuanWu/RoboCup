# IAR project LPLD_Template_K60.ewp, settings and files
configuration RAM (ARM, debug)
  General.OGChipSelectEditMenu: MK60DX256xxx10 Freescale MK60DX256xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; LPLD_K60
  ICCARM.CCIncludePath2: ..\app; ..\..\..\lib\common; ..\..\..\lib\cpu; ..\..\..\lib\cpu\headers; ..\..\..\lib\drivers\adc16; ..\..\..\lib\drivers\enet; ..\..\..\lib\drivers\lptmr; ..\..\..\lib\drivers\mcg; ..\..\..\lib\drivers\pmc; ..\..\..\lib\drivers\rtc; ..\..\..\lib\drivers\uart; ..\..\..\lib\drivers\wdog; ..\..\..\lib\platforms; ..\..\..\lib\LPLD; ..\..\..\lib\LPLD\FatFs; ..\..\..\lib\LPLD\USB; ..\..\..\lib\iar_config_files
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LPLD_Template_K60.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\lib\iar_config_files\64KB_Ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FLASH (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: D:\robot\lib\iar_config_files\128KB_Pflash_128KB_Dflash.icf
  group app
    ../app/: car.c car.h config.c config.h control.c control.h infrare.c infrare.h isr.h led.c led.h LPLD_Template.c motor.c motor.h move.c move.h nothing.c nothing.h util.c util.h zigbee.c zigbee.h
  group lib/common
    ../../../lib/common/: alloc.c assert.c assert.h common.h io.c io.h memtest.c memtest.h printf.c queue.c queue.h startup.c startup.h stdlib.c stdlib.h uif.c uif.h
  group lib/cpu
    ../../../lib/cpu/: arm_cm4.c arm_cm4.h crt0.s dma_channels.h start.c start.h sysinit.c sysinit.h vectors.c vectors.h
  group lib/cpu/headers
    ../../../lib/cpu/headers/: MK10DZ10.h MK20DZ10.h MK30DZ10.h MK40DZ10.h MK50DZ10.h MK51DZ10.h MK52DZ10.h MK53DZ10.h MK60DZ10.h
  group lib/drivers/adc16
    ../../../lib/drivers/adc16/: adc16.c adc16.h
  group lib/drivers/enet
    ../../../lib/drivers/enet/: enet.c enet.h eth.h eth_phy.c eth_phy.h mii.c mii.h nbuf.c nbuf.h
  group lib/drivers/lptmr
    ../../../lib/drivers/lptmr/: lptmr.c lptmr.h
  group lib/drivers/pmc
    ../../../lib/drivers/pmc/: pmc.c pmc.h
  group lib/drivers/rtc
    ../../../lib/drivers/rtc/: rtc.c rtc.h
  group lib/drivers/uart
    ../../../lib/drivers/uart/: uart.c uart.h
  group lib/drivers/wdog
    ../../../lib/drivers/wdog/: wdog.c wdog.h
  group lib/LPLD
    ../../../lib/LPLD/: FML_DiskIO.c FML_DiskIO.h HAL_ADC.c HAL_ADC.h HAL_CAN.c HAL_CAN.h HAL_DAC.c HAL_DAC.h HAL_Def.h HAL_eDMA.c HAL_eDMA.h HAL_ENET.c HAL_ENET.h HAL_FTM.c HAL_FTM.h HAL_GPIO.c HAL_GPIO.h HAL_I2C.c HAL_I2C.h HAL_LPTMR.c HAL_LPTMR.h HAL_MCG.c HAL_MCG.h HAL_PDB.c HAL_PDB.h HAL_PIT.c HAL_PIT.h HAL_RTC.c HAL_RTC.h HAL_SDHC.c HAL_SDHC.h HAL_SPI.c HAL_SPI.h HAL_UART.c HAL_UART.h HAL_USB_Device.c HAL_USB_Device.h
  group lib/LPLD/FatFs
    ../../../lib/LPLD/FatFs/: ff.c ff.h ffconf.h integer.h
  group lib/LPLD/FatFs/option
    ../../../lib/LPLD/FatFs/option/: ccsbcs.c syscall.c
  group lib/LPLD/USB
    ../../../lib/LPLD/USB/: FslTypes.h RingBuffer.c RingBuffer.h USB.c USB.h USB_CDC.c USB_CDC.h USB_Desc.h
  group lib/platform
    ../../../lib/platforms/: k60_card.h
